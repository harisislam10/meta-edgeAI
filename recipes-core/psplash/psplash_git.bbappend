SPLASH_IMAGES = "file://psplash-poky-img2.png;outsuffix=default"
FILESEXTRAPATHS:prepend: := "${THISDIR}/files:"
